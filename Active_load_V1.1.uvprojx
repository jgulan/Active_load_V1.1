# Keil uVision project Active_load_V1.1.uvprojx, settings and files
target M0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1112FD20/102 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Active_load_V1.1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source
    ./Source/: main.c PIOinit.c LCDinit.h LCDinit.c PIOinit.h PWMinit.h PWMinit.c ADCinit.c ADCinit.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
